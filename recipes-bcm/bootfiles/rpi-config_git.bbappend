inherit technux-rpi-common

