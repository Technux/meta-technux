# This bbappend is only used for demo the usage of debug.bbclass.

FILESEXTRAPATHS =. "${FILE_DIRNAME}/technux:"

inherit debug
