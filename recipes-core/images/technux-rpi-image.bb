inherit technux-image-common
inherit sdcard_image-rpi

RNAME = "Technux RPi"

