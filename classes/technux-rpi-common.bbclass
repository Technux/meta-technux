COMPATIBLE_MACHINE_technux-rpi = "technux-rpi"

